Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-23T10:47:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 23 10:47:22 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{039C224E-B037-4F9A-8089-CB0798370FDF}\ifc * Database version: 5507 * Database creation date: Fri Aug 23 10:47:21 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 23 10:47:21 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 23 10:47:21 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 533 Hand shower set, 533(2016):533 Hand shower set:400446
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 58.4 mm; NominalHeight: 345.1 mm; NominalWidth: 95.9 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 533(2016); ConvergoRefNr: 0087-1909-0076-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 23/07/2019
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150077586; EN Standard: EN 1112; LVI Number: 6510166; NRF Number: 4203416; RSK Number: 8320087; VVS Number: 737758234
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/533; Catalog Drawing URL: http://static.oras.com/catdrw/533; Dimension Drawing URL: http://static.oras.com/dimdrw/533; FDV Document URL: http://www.oras.com/datasheet/533/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/533; Group: Hand showers and shower sets; Long Marketing: Oras Apollo shower set including hand shower, wall bracket and a 1500 mm shower hose; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 533 Hand shower set; Name_en: 533 Hand shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package Weight: 0.460 kg; Product Code: 533; Product Datasheet: http://www.oras.com/datasheet/533/en; Product Family: Oras Apollo; Product Image URL: http://static.oras.com/image/533; Product URL: http://static.oras.com/533; Type Name: 533 Hand shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Flow Rate At 300kPa: 0.0105944 m3/s; Hand Shower Size: Ø 95 mm; Installation and Maintenance: http://static.oras.com/manual/533; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Shower holder;Hand shower;Shower Hose (1500 mm)
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 533(2016); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 533; Name: 533 Hand shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 95x60x345 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 533; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 533 Hand shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0588368 m2; Volume: 0.00193207 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 533(2016): 533 Hand shower set; Family and Type: 533(2016): 533 Hand shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 533(2016): 533 Hand shower set; Type Id: 533(2016): 533 Hand shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
